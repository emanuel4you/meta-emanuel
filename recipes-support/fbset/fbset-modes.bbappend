PR = "r7"

SRC_URI = "file://fb.modes"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
